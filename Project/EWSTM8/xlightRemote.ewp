# IAR project xlightRemote.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; RAM_EXECUTION
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\xlightCommon-stm8s\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: remoteV1.0.1.0_home.hex
  ILINK.IlinkOutputFile: xlightRemote.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group STM8L Library/inc
    ../../../xlightCommon-stm8s/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_spi.h stm8l15x_tim4.h stm8l15x_wwdg.h
  group STM8L Library/src
    ../../../xlightCommon-stm8s/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_spi.c stm8l15x_tim4.c stm8l15x_wwdg.c
  group User/inc
    ../inc/: _global.h button.h common.h delay.h MyMessage.h PPTCtrl_Protocol.h ProtocolParser.h publicDefine.h rf24l01.h stm8l15x_conf.h stm8l15x_it.h timer.h xliNodeConfig.h
  group User/src
    ../src/: button.c common.c delay.c main.c ProtocolParser.c rf24l01.c stm8l15x_it.c timer.c
